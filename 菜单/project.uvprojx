# Keil uVision project project.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\CMSIS\startup;.\CMSIS;.\FWlib\inc;.\Src;.\User;.\Public;.\Src\i2c_oled;.\Src\menu;.\Src\key
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ./FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c
  group PUBLIC
    ./Public/: system.c usart.c systick.c
  group USER
    ./User/: main.c stm32f10x_it.c
  group SRC
    ./Src/i2c_oled/: oled.c
    ./Src/menu/: menu.c
    ./Src/key/: key.c
  group DOC
    ./Doc/: readme.txt
