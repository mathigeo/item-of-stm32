# Keil uVision project project.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\CMSIS\startup;.\CMSIS;.\FWlib\inc;.\Src;.\User;.\Public;.\Src\oled;.\Src\adc;.\Src\encoder;.\Src\mpu6050\I2C;.\Src\mpu6050\mpu_exit;.\Src\mpu6050\mpu6050;.\Src\mpu6050\mpu6050\eMPL;.\Src\wheel;.\Src\control;.\Src\servo;.\Src\n20
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ./FWlib/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c
  group PUBLIC
    ./Public/: system.c usart.c systick.c
  group USER
    ./User/: main.c stm32f10x_it.c
  group SRC
    ./Src/oled/: oled.c
    ./Src/adc/: adc.c
    ./Src/encoder/: encoder.c
    ./Src/mpu6050/I2C/: i2c.c
    ./Src/mpu6050/mpu6050/: mpu6050.c
    ./Src/mpu6050/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./Src/mpu6050/mpu_exit/: mpu_exti.c
    ./Src/wheel/: wheel.c
    ./Src/control/: control.c
    ./Src/servo/: servo.c
    ./Src/n20/: n20.c
  group DOC
    ./Doc/: readme.txt
